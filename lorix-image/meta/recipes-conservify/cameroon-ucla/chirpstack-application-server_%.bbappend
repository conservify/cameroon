FILESEXTRAPATHS_prepend := "${THISDIR}/chirpstack:"
