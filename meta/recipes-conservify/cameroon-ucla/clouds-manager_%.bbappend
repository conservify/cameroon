FILESEXTRAPATHS_prepend := "${THISDIR}/clouds-manager:"
